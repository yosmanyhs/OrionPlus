# Keil uVision project OrionPlus.uvprojx, settings and files
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OrionPlus
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Sources\Configs;.\Sources\App\Inc;.\Sources\Drivers\Inc;.\Sources\OS\FreeRTOS\Inc;.\Sources\Graphics\uGFX\Inc;.\Sources\Graphics\uGFX\Inc\library;.\Sources\Graphics\uGFX\Inc\library\gdisp;.\Sources\Graphics\uGFX\Inc\library\gdisp\fonts;.\Sources\Graphics\uGFX\Inc\library\gdisp\mcufont;.\Sources\Graphics\uGFX\Inc\library\gdriver;.\Sources\Graphics\uGFX\Inc\library\gevent;.\Sources\Graphics\uGFX\Inc\library\gfile;.\Sources\Graphics\uGFX\Inc\library\ginput;.\Sources\Graphics\uGFX\Inc\library\gos;.\Sources\Graphics\uGFX\Inc\library\gqueue;.\Sources\Graphics\uGFX\Inc\library\gtimer;.\Sources\Graphics\uGFX\Inc\library\gwin;.\Sources\Graphics\uGFX\Inc\library\rom_files;.\Sources\Graphics\uGFX\Inc\drivers\gdisp;.\Sources\Graphics\uGFX\Inc\drivers\ginput;.\Sources\Graphics\uGFX\Inc\custom;.\Sources\Graphics\uGFX\Src\library\gdisp\fonts;.\Sources\Graphics\uGFX\Src\library\rom_files;.\Sources\App\Inc\pages
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Configs
    ./Sources/Configs/: pins.h stm32f4xx_hal_conf.h FreeRTOSConfig.h FreeRTOSFATConfig.h
    ./Sources/Graphics/lvgl/: lv_conf.h
  group App_Core
    ./Sources/App/Src/: main.cpp tick_control.cpp settings_manager.cpp user_tasks.cpp MachineCore.cpp
  group App_HW
    ./Sources/App/Src/: adc.cpp uart_ports.cpp spi_ports.cpp hw_timers.cpp fsmc.cpp dma.cpp gpio.cpp disk_task.cpp usb_task.cpp serial_task.cpp
  group App_UI
    ./Sources/App/Src/: ui_task.cpp ControlBar.cpp PageManager.cpp BasePage.cpp
    ./Sources/App/Src/pages/: MainPage.cpp FileManagerPage.cpp
  group App_GCode
    ./Sources/App/Src/: gcode_parsing_task.cpp DataConverter.cpp GCodeParser.cpp CoolantController.cpp SpindleController.cpp
  group App_Motion
    ./Sources/App/Src/: Planner.cpp Block.cpp Conveyor.cpp BlockQueue.cpp StepTicker.cpp
  group Drivers
    ./Sources/Drivers/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_exti.c
  group OS
    ./Sources/OS/FreeRTOS/Src/: event_groups.c heap_4.c list.c port.c queue.c stream_buffer.c tasks.c timers.c
    ./Sources/App/Src/: os_hooks.cpp memory_wrappers.cpp
  group FileSystem
    ./Sources/OS/FreeRTOS/plus/fat/: ff_crc.c ff_dev_support.c ff_dir.c ff_error.c ff_fat.c ff_file.c ff_format.c ff_ioman.c ff_locking.c ff_memory.c ff_stdio.c ff_string.c ff_sys.c ff_time.c
    ./Sources/OS/FreeRTOS/plus/fat/portable/STM32F4xx/: ff_sddisk.c
  group LittleVGL_Core
    ./Sources/Graphics/lvgl/src/lv_core/: lv_debug.c lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group LittleVGL_HAL
    ./Sources/Graphics/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group LittleVGL_Misc
    ./Sources/Graphics/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
  group LittleVGL_Draw
    ./Sources/Graphics/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
  group LittleVGL_Font
    ./Sources/Graphics/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_12_subpx.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_roboto_28_compressed.c lv_font_unscii_8.c
  group LittleVGL_ObjX
    ./Sources/Graphics/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_cpicker.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
  group LittleVGL_Themes
    ./Sources/Graphics/lvgl/src/lv_themes/: lv_theme.c lv_theme_default.c
  group LittleVGL_Drivers
    ./Sources/Graphics/lvgl/src/lv_drivers/: driver_screen_NT35510.c driver_touch_GT9147.c
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: OrionPlus_D
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE, __USE_C99_MATH
  c include: .\Sources\Configs;.\Sources\App\Inc;.\Sources\Drivers\Inc;.\Sources\OS\FreeRTOS\Inc;.\Sources\Graphics\uGFX\Inc;.\Sources\Graphics\uGFX\Inc\library;.\Sources\Graphics\uGFX\Inc\library\gdisp;.\Sources\Graphics\uGFX\Inc\library\gdisp\fonts;.\Sources\Graphics\uGFX\Inc\library\gdisp\mcufont;.\Sources\Graphics\uGFX\Inc\library\gdriver;.\Sources\Graphics\uGFX\Inc\library\gevent;.\Sources\Graphics\uGFX\Inc\library\gfile;.\Sources\Graphics\uGFX\Inc\library\ginput;.\Sources\Graphics\uGFX\Inc\library\gos;.\Sources\Graphics\uGFX\Inc\library\gqueue;.\Sources\Graphics\uGFX\Inc\library\gtimer;.\Sources\Graphics\uGFX\Inc\library\gwin;.\Sources\Graphics\uGFX\Inc\library\rom_files;.\Sources\Graphics\uGFX\Inc\drivers\gdisp;.\Sources\Graphics\uGFX\Inc\drivers\ginput;.\Sources\Graphics\uGFX\Inc\custom;.\Sources\Graphics\uGFX\Src\library\gdisp\fonts;.\Sources\Graphics\uGFX\Src\library\rom_files;.\Sources\App\Inc\pages;.\Sources\Graphics\lvgl;.\Sources\Graphics\lvgl\src;.\Sources\Graphics\lvgl\src\lv_core;.\Sources\Graphics\lvgl\src\lv_draw;.\Sources\Graphics\lvgl\src\lv_font;.\Sources\Graphics\lvgl\src\lv_hal;.\Sources\Graphics\lvgl\src\lv_misc;.\Sources\Graphics\lvgl\src\lv_objx;.\Sources\Graphics\lvgl\src\lv_themes;.\Sources\Graphics\lvgl\src\lv_drivers;.\Sources\OS\FreeRTOS\plus\fat\include;.\Sources\OS\FreeRTOS\plus\fat\portable\common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --verbose --list err.txt
target Debug_RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: as above
  output: OrionPlus_D
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: LV_CONF_INCLUDE_SIMPLE, __USE_C99_MATH, VECT_TAB_SRAM
  c include: as above
  memory RVCT4: ROM 0x20000000 size 0x14000
  memory RVCT9: RAM 0x20014000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --verbose --list err.txt
software components: CMSIS:CORE 5.3.0, CMSIS:DSP 1.7.0, Device:Startup 2.6.3
